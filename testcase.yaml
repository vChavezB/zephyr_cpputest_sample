## testcase.yaml
```yaml
tests:
  my_tests.my_test_group:
    platform_allow:
    - native_posix/native/64
    harness: "cpputest"
```
